# Keil uVision project TSL108.uvproj, settings and files
target ble_simple_peripheral (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TSL108
  AfterMake: fromelf.exe  --text  -c -o Output/TSL108.txt  Objects/TSL108.axf
  AfterMake: fromelf.exe  --bin -o Output/TSL108.bin  Objects/TSL108.axf
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LV_BUILD_TEST=1,LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --preinclude app_config.h --locale=english --diag_suppress=188 --diag_suppress=1
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_simple_profile;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\platform\include\cmsis;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\modules\gui\lvgl_8_1\lvgl;..\..\..\..\components\modules\gui\lvgl_8_1\lvgl_example;..\..\..\..\components\driver\drv_common;..\..\..\..\components\driver\components\display;..\..\..\..\components\driver\components\touchpad;..\code;..\code\scroll_menu;..\..\..\..\components\modules\gui\lvgl_8_1\lvgl\src\misc;..\code\window;..\code\language;..\code\Jlink_RTT;..\code\button_driver;..\code\picture;..\..\..\..\components\ble\profiles\ble_ota;..\code\user_app;..\..\..\..\components\modules\gui\lvgl_8_1\lvgl\src\core
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x23000000 size 0x100000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: ..\..\..\..\components\toolchain\armcc\fr800x.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ble_simple_peripheral.c ble_simple_peripheral.h user_task.c gui_main.c app_at.c gif_decoder.c
    ../../../../components/modules/common/src/: co_log.c
  group user_app
    ../code/user_app/: user_knob_home.c user_knob_led.c user_knob_main.c user_knob_power.c user_knob_setting.c user_knob_temp.c user_knob_wash.c user_knob_water_level.c
  group sensor
    ../code/: input_driver.c key_driver.c driver_ktm57xx.c
  group profiles
    ../../../../components/ble/profiles/ble_simple_profile/: simple_gatt_service.c simple_gatt_service.h
    ../../../../components/ble/profiles/ble_ota/: ota.c ota_service.c
  group driver
    ../../../../components/driver/: driver_pmu.c driver_psram.c driver_timer.c driver_dma.c driver_gpio.c driver_exti.c driver_spi_master.c driver_i2c.c driver_if8080.c driver_uart_ex.c
    ../../../../components/driver/components/touchpad/: driver_cst816d.c
  group platform
    ../../../../components/modules/platform/src/keil/: boot_vectors.s
  group lib
    ../../../../components/ble/library/: fr8000_stack.lib
  group lvgl
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/widgets/win/: lv_win.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/extra/: lv_extra.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_32.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_printf.c lv_math.c lv_mem.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_example
    ../../../../components/modules/gui/lvgl_8_1/lvgl_example/src/lv_demo_benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl_example/src/lv_demo_benchmark/: lv_demo_benchmark.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl_example/src/lv_demo_stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl_example/src/lv_demo_widgets/: lv_demo_widgets.c
    ../../../../components/modules/gui/lvgl_8_1/lvgl_example/src/lv_demo_widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group fonts
    ../code/font/: language_36.c language_72.c language_16.c
  group picture
    ../code/picture/: picture.h picture.c picture_define.h
  group display
    ../../../../components/driver/components/display/: driver_display.c driver_gc9c01.c driver_jd9854.c driver_nv3041a.c driver_st7789v.c driver_st77903.c driver_st7796s.c driver_gc9a01.c driver_st7365.c driver_nv3030b.c
